<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Dual_AlternateTrigger.ewp</path>
  </project>
  <batchBuild/>
</workspace>


