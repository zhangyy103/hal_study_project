# Keil uVision project Dual_Combined_Reg_Inj_Simultaneous.uvproj, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Dual_Combined_Reg_Inj_Simultaneous
  c flags: Optim=3 OneElfS=1
  c define: USE_STM3210B_EVAL,STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Doc
    ../: readme.txt
  group RVMDK
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c misc.c stm32f10x_dma.c
  group User
    ../src/: main.c stm32f10x_it.c
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Dual_Combined_Reg_Inj_Simultaneous
  c flags: Optim=4 OneElfS=1
  c define: USE_STM3210E_EVAL,STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM3210C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Dual_Combined_Reg_Inj_Simultaneous
  c flags: Optim=4 OneElfS=1
  c define: USE_STM3210C_EVAL,STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
